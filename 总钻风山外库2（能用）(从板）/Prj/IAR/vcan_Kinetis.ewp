# IAR project vcan_Kinetis.ewp, settings and files
configuration FN15_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FN1M0xxx15 NXP MK60FN1M0xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60F15; MK60FN15
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB; K:\飞思卡尔\程序\VB2017\单拉程序包(K60)(从板）; K:\飞思卡尔\资料\小小飞侠24 2019十四届信标组软硬件资料\程序\Libraries\my_freescale\OTSU; K:\飞思卡尔\程序\VB2017\雷达; F:\救救小车\定稿工程\程序\VB2017\单拉程序包(K60)(从板）; F:\程序\定稿工程\程序\VB2017\单拉程序包(K60)(从板）; F:\程序\VB2017\单拉程序包(K60)
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vcan_Kinetis.hex
  ILINK.IlinkOutputFile: vcan_Kinetis.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N1M.icf
  ILINK.IlinkAdditionalLibs: ..\..\Lib\CMSIS\iar_cortexM4l_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FN15_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FN1M0xxx15 Freescale MK60FN1M0xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60F15; MK60FN15
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: vcan_Kinetis.srec
configuration FX15_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FX512xxx15 NXP MK60FX512xxx15
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60F15; MK60FX15
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB; F:\救救小车\小小飞侠24 2019十四届信标组软硬件资料\程序\Libraries\my_freescale\OTSU; F:\救救小车\定稿工程\程序\VB2017\单拉程序包(K60)(从板）; F:\救救小车\定稿工程\程序\VB2017\20190325; F:\救救小车\定稿工程\程序\VB2017\雷达
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60X512.icf
configuration FX15_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60F15; MK60FX15
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
configuration DZ10_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 NXP MK60DN512xxx10
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: config files\vcan_RAM_K60N512.icf
configuration DZ10_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
  group App
    ../../App/: main.c MK60_conf.c MK60_it.c
    ../../App/Inc/: MK60_conf.h MK60_it.h PORT_cfg.h
  group App/lidar
    ../../App/: lidar.c lidar.h
  group App/own
    ../../App/: analayse.h analyse.c analysis.h circleflag.c circleflag.h constant.h encoder.c Encoder1.h enter.h init.c init.h interrupt.c interrupt.h LCD_menu.c LCD_menu.h motor.h OTSU.c OTSU.h PID.h Send.c Send.h
  group Board
    ../../Board/src/: font.c SEEKFREE_18TFT.c SEEKFREE_IIC.c SEEKFREE_MT9V032.c SEEKFREE_OLED.c VCAN_ASCII.c VCAN_BMP.c VCAN_camera.c VCAN_computer.c vcan_img2sd.c VCAN_key.c VCAN_key_event.c VCAN_LCD.c VCAN_LCD_CH.c VCAN_LCD_ILI9341.c VCAN_LCD_ST7735R.c VCAN_LCD_ST7735S.c VCAN_LED.C VCAN_MMA7455.c VCAN_NRF24L0.c VCAN_NRF24L0_MSG.c VCAN_OV7725_Eagle.c VCAN_OV7725_Wolf.c VCAN_RTC_count.C VCAN_SCCB.c vcan_sd_app.c Vcan_touch.c VCAN_TSL1401.c VCAN_UI_VAR.c
  group Chip
    ../../Chip/inc/: common.h
    ../../Chip/src/: misc.c MK60_adc.c MK60_can.c MK60_dac.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_flexbus.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_usb.c MK60_wdog.c vectors.c
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
  group LIB/FatFs
    ../../Lib/FatFs/: diskio.c ff.c
  group LIB/USB
    ../../Lib/USB/: USB.c USB_CDC.c
